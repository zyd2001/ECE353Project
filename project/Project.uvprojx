# Keil uVision project Project.uvprojx, settings and files
target Project-F19 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c main.h project_hardware_init.c project_hardware_init.h project_interrupts.c project_interrupts.h project_logic.c project_logic.h project_graphics.c project_graphics.h project_images.c project_images.h project_utility.c project_utility.h
  group drivers
    ../drivers/c/: adc.c gpio_port.c i2c.c pc_buffer.c spi.c timers.c uart.c
  group peripherals
    ../peripherals/c/: accel.c eeprom.c ft6x06.c launchpad_io.c lcd.c ps2.c serial_debug.c spi_select.c ws2812b.s
    ./: mcp23017.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
